# Keil uVision project BTSsystem.uvproj, settings and files
target BTS (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BTSsystem +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\HardWare;.\EEPROM;.\Delay
  group User
    ./User/: main.c
  group HardWare
    ./HardWare/: Buzzer.c Buzzer.h DS18B20.c DS18B20.h LCD1602.c LCD1602.h MatrixKey.c MatrixKey.h OneWire.c OneWire.h DDTube.c DDTube.h Timer.c Timer.h
  group EEPROM
    ./EEPROM/: AT24C02.c AT24C02.h I2C.c I2C.h
  group Delay
    ./Delay/: Delay.c Delay.h
